# Keil uVision project C10B_Trace_SpeedTest.uvprojx, settings and files
target C10B_Trace_SpeedTest (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: C10B_Trace_SpeedTest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CMSIS;..\FWLib\inc;..\BSP;..\BSP\delay;..\BSP\motor;..\BSP\Timer;..\BSP\USART;..\BSP\Grayscale_Sensor;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c switch_function.h AllHeader.h
  group CMSIS
    ../CMSIS/: system_stm32f10x.c core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/delay/: delay.c
    ../BSP/: bsp.c
    ../BSP/motor/: bsp_motor.c bsp_encoder.c
    ../BSP/Timer/: bsp_timer.c
    ../BSP/USART/: bsp_usart.c
    ../BSP/Grayscale_Sensor/: grayscale_sensor.c
  group APP
    ../APP/: app_motor.c PID_Motor.c trace_task.c trace_task.h trace_config.h odometry.c odometry.h rdk_link.c rdk_link.h gcs_cmd.c gcs_cmd.h
